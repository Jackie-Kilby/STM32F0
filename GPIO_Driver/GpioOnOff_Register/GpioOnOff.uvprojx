# Keil uVision project GpioOnOff.uvprojx, settings and files
target GPIO_Demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030F4Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: GpioOnOff
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HAL_GPIO_MODULE_ENABLED
  c include: ..\..\STM32F0xx_StdPeriph_Lib_V1.5.0\Libraries\STM32F0xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Source
    ./: main.c gpio.c led.c timer.c rtc.c soft_timer.c sys_timer.c
  group Include
    ./: gpio.h led.h timer.h rtc.h soft_timer.h sys_timer.h
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.0
